## base_external/package/aesd-final/Config.in
```kconfig
config BR2_PACKAGE_AESD_FINAL
	bool "aesd-final"
	help
	  Includes the package for the final project
```
